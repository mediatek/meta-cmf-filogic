RDEPENDS:${PN}:remove = "elfutils"
RDEPENDS:${PN}-tests:append = " bash" 