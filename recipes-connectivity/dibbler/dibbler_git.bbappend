SRC_URI:remove = "file://Configurable-WanName-NotifyScript-mapT.patch"