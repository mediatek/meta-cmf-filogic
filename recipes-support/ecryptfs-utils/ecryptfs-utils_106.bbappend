SRC_URI:append_kirkstone = "\
           file://0001-ecryptfs-patch-for-openssl-1.x.patch \
           "

