CFLAGS:append = " -D_PLATFORM_RASPBERRYPI_"
