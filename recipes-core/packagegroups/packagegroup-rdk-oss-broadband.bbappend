RDEPENDS:packagegroup-rdk-oss-broadband:remove = "alljoyn"
RDEPENDS:packagegroup-rdk-oss-broadband:remove = " zilker-sdk"
